#define DBG_LEVEL           DBG_INFO
#define DBG_SECTION_NAME    "util"
#include <rtdbg.h>

#include <rtthread.h>
#include <stdbool.h>
#include <string.h>
#include <stdio.h>
#include <string.h>
#include <rtdbg.h>

#include "utils.h"

unsigned char xor8_computer(unsigned char * p_data, unsigned int len){
	unsigned char xor = 0;
	unsigned int i;

	for(i=0;i<len;i++)
	{
		xor ^= p_data[i];
	}
		
	return xor;
}

//BCD码转换
#define bin2bcd(bin)  ( (((bin)/10) << 4) | ((bin)%10) )
#define bcd2bin(bcd)  ( ((bcd)&0x0f) + ((((bcd)>>4)&0x0f)*10) )


unsigned int power(int base, int times) 
{
	int i;
	unsigned int rusult = 1;
	
	for(i=0;i < times; i++)
		rusult *= base;

	return rusult;
}

/*
* 十进制转化为bcd  码
* @dec : 十进制的值
* @buf : 存放bcd  的缓存
* @len : bu  存放bcd缓存的长度
* @return : buf  中的有效数据开始位置
*/
int decimal2bcd(unsigned int dec,unsigned char *buf, int len)
{
	int i;
	unsigned temp;

	//DbgPrintf("dec = %d\r\n",dec);
	//DbgPrintf("len = %d\r\n",len);

	memset(buf,0x00,len);
	
	for(i=len-1;i>=0;i--)
	{
		if(dec == 0)
			break;
			
		temp = dec % 100;		
		buf[i] = ((temp/10) << 4) | ((temp % 10) & 0x0F);   
		dec /= 100;


		//DbgPrintf("temp = %d\r\n",temp);
		//DbgPrintf("dec = %d\r\n",dec);
		//DbgPrintf("val = %d\r\n",buf[i]);

	}
	
	return i+1;
}

/*
* bcd码转化为十进制
* @buf : 存放bcd的缓存
* @len : 存放bcd缓存的长度
* @return : 返回十进制的数据
*/
unsigned int bcd2decimal(unsigned char *buf, int len)
{
	int	i;
	unsigned int tmp;
	unsigned int dec = 0;
	
	for(i=0;i<len;i++)
	{
		tmp = ((buf[i] >> 4) & 0x0F) * 10 + (buf[i]&0x0F);
		dec += tmp * power(100, len-1-i);    
	}

	return dec;
}

bool is_bcd(unsigned char *buf, int len)
{
	int i;
	
	for(i=0; i<len; i++)
	{
		if((((buf[i] >> 4) & 0x0F) > 0x09) || ((buf[i]  & 0x0F) > 0x09))
			return false;
	}

	return true;
}

char __getHexCharForDigit(int val){
	if(val < 10){
		return '0'+val;
	}
	return 55 + val; //A(65)+val-10
}

int __getDigitForHexChar(char ch){
	if(ch >= '0' && ch <= '9'){
		return ch - '0';
	}
	if(ch >= 'A' && ch <= 'F'){
		return ch-'A' + 10;
	}
	if(ch >= 'a' && ch <= 'f'){
		return ch-'a' + 10;
	}
	return -1;
}

int str2BCDByteArray(char *str,unsigned char *bcdByteArray){
	if(!str){
		return 1;
	}
	int len = strlen(str),tempDigit,realNum = 0;
	char *startRecord = str;
	if((len%2) == 1){
		tempDigit = __getDigitForHexChar(*startRecord);
		if(tempDigit < 0){
			return 2;
		}
		*bcdByteArray = tempDigit;
		startRecord +=1;
		len -= 1;
		realNum = 1;
	}
	int num = len/2,val;
	char *record = (char*)bcdByteArray+realNum;
	realNum += num;

	int i;
	for(i=0;i<num;i++){
		tempDigit = __getDigitForHexChar(*startRecord);
		if(tempDigit < 0){
			return -2;
		}
		val = tempDigit << 4;
		tempDigit = __getDigitForHexChar(*(startRecord+1));
		if(tempDigit < 0){
			return -2;
		}
		*record = val + tempDigit;

		record += 1;
		startRecord += 2;
	}

	return realNum;
}
int bcdByteArray2Str(unsigned char *bcdByteArray,int len,char *str){
	if(!bcdByteArray || !str){
		return 1;
	}
	if(len < 0){
		return 2;
	}

	char *temp = (char*)bcdByteArray;
	char *dest = str;
	int i,val;
	for(i=0;i<len;i++){
		val = *temp & 0xFF;

		*(dest++) = __getHexCharForDigit(val/16);
		*(dest++) = __getHexCharForDigit(val%16);

		temp ++;
	}
	*(dest++) = 0;

	return 2*len;
}


void bcdtime_to_char(unsigned char *bcd_time,unsigned char* str_time)
{
	
	DbgFuncEntry();
	unsigned int year,mon,day,hour,min,sec;
	
	year = bcd2decimal(bcd_time++,1);
	mon  = bcd2decimal(bcd_time++,1);
	day  = bcd2decimal(bcd_time++,1);
	hour = bcd2decimal(bcd_time++,1);
	min  = bcd2decimal(bcd_time++,1);
	sec  = bcd2decimal(bcd_time++,1);
	
	sprintf((char*)str_time,"%d-%02d-%02d %02d:%02d:%02d",year+2000,mon,day,hour,min,sec);
	DbgFuncExit();
	return;
}

void bcdtime_to_dvr_time(unsigned char *bcd_time,unsigned char* str_time)
{
	
	DbgFuncEntry();
	unsigned int year,mon,day,hour,min,sec;
	
	year = bcd2decimal(bcd_time++,1);
	mon  = bcd2decimal(bcd_time++,1);
	day  = bcd2decimal(bcd_time++,1);
	hour = bcd2decimal(bcd_time++,1);
	min  = bcd2decimal(bcd_time++,1);
	sec  = bcd2decimal(bcd_time++,1);
	
	sprintf((char*)str_time,"%04d%02d%02d-%02d%02d%02d",year+2000,mon,day,hour,min,sec);
	DbgFuncExit();
	return;
}

#define LINE_PRINT_BYTES (16)
#ifdef DEBUG_APP
void debug_print_block_data(uint32_t base_address,uint8_t* data_ptr,uint32_t block_size){
	int i,j,vaild_count;
	int valid_flag=0;
	int print_line = block_size/LINE_PRINT_BYTES+((block_size%LINE_PRINT_BYTES>0)?1:0);
	int line_base_address=0;
	int line_offset=0;
	//print base address info
	LOG_I("flash read back add:[0x%08x]",base_address);
	LOG_I("flash read back ptr:[0x%08x]",(uint32_t)data_ptr);
	#if 1
	for (i = 0; i < print_line; i++){
		vaild_count =0;
		line_offset = (i*LINE_PRINT_BYTES);
		line_base_address = base_address + line_offset;
		for(j=line_offset;j<line_offset+LINE_PRINT_BYTES;j++)
		{
			if (data_ptr[j] != 0xFF){vaild_count++;}
		}
		if(vaild_count>0){
				LOG_I("data[%08x] %02x %02x %02x %02x %02x %02x %02x %02x  %02x %02x %02x %02x %02x %02x %02x %02x",
					line_base_address,
					data_ptr[line_offset],data_ptr[line_offset+1],data_ptr[line_offset+2],data_ptr[line_offset+3],
					data_ptr[line_offset+4],data_ptr[line_offset+5],data_ptr[line_offset+6],data_ptr[line_offset+7],
					data_ptr[line_offset+8],data_ptr[line_offset+9],data_ptr[line_offset+10],data_ptr[line_offset+11],
					data_ptr[line_offset+12],data_ptr[line_offset+13],data_ptr[line_offset+14],data_ptr[line_offset+15]);
		}
		
	}
	#endif
}
#else
void debug_print_block_data(uint32_t base_address,uint8_t* data_ptr,uint32_t block_size){
	return;
}
#endif
#include "MicroNMEA.h"
void debug_utc(time_t time_utc)
{
	DateTime datetime;
	datetime = makeDateTime_utc_zone(time_utc,0);
	LOG_I("datetime:%04d-%02d-%02d %02d:%02d:%02d/WEEK:%d",
	datetime._year,datetime._month,datetime._day,
	datetime._hour,datetime._minute,datetime._second,
	datetime._week);
}

uint32_t OSTimeGet()
{
	rt_tick_t tick = 0;
  tick = rt_tick_get();
	if(tick <RT_TICK_PER_SECOND) return 0;
	return tick/RT_TICK_PER_SECOND;
}

uint32_t OSTimeGetMS(){
	rt_tick_t tick = 0;
	tick = rt_tick_get();
	if(tick <(rt_tick_from_millisecond(1))) return 0;
	return tick*1000/(RT_TICK_PER_SECOND);
}

static const unsigned char aucCRCHi[] =
{
        0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
        0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
        0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
        0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
        0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
        0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
        0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
        0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
        0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
        0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
        0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
        0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
        0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
        0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
        0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
        0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
        0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
        0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
        0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
        0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
        0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
        0x00, 0xC1, 0x81, 0x40
};

static const unsigned char aucCRCLo[] =
{
        0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 0x07, 0xC7,
        0x05, 0xC5, 0xC4, 0x04, 0xCC, 0x0C, 0x0D, 0xCD, 0x0F, 0xCF, 0xCE, 0x0E,
        0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09, 0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9,
        0x1B, 0xDB, 0xDA, 0x1A, 0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC,
        0x14, 0xD4, 0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,
        0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 0xF2, 0x32,
        0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4, 0x3C, 0xFC, 0xFD, 0x3D,
        0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A, 0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38,
        0x28, 0xE8, 0xE9, 0x29, 0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF,
        0x2D, 0xED, 0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,
        0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60, 0x61, 0xA1,
        0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67, 0xA5, 0x65, 0x64, 0xA4,
        0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F, 0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB,
        0x69, 0xA9, 0xA8, 0x68, 0x78, 0xB8, 0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA,
        0xBE, 0x7E, 0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
        0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 0x70, 0xB0,
        0x50, 0x90, 0x91, 0x51, 0x93, 0x53, 0x52, 0x92, 0x96, 0x56, 0x57, 0x97,
        0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C, 0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E,
        0x5A, 0x9A, 0x9B, 0x5B, 0x99, 0x59, 0x58, 0x98, 0x88, 0x48, 0x49, 0x89,
        0x4B, 0x8B, 0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,
        0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 0x43, 0x83,
        0x41, 0x81, 0x80, 0x40
};

unsigned short usMBCRC16( unsigned char * pucFrame, unsigned short usLen )
{
    unsigned char           ucCRCHi = 0xFF;
    unsigned char           ucCRCLo = 0xFF;
    int             iIndex;

    while( usLen-- )
    {
        iIndex = ucCRCLo ^ *( pucFrame++ );
        ucCRCLo = ( unsigned char )( ucCRCHi ^ aucCRCHi[iIndex] );
        ucCRCHi = aucCRCLo[iIndex];
    }
    return ( unsigned short  )( ucCRCHi << 8 | ucCRCLo );
}