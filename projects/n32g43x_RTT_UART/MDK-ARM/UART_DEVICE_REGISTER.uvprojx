# Keil uVision project UART_DEVICE_REGISTER.uvprojx, settings and files
target N32G43x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G435RB Nationstech
  pack: Nationstech.N32G43x_DFP.0.9.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UART_DEVICE_REGISTER
  AfterMake: fromelf --bin --output=.\bin\UART_DEVICE_REGISTER.bin .\Objects\UART_DEVICE_REGISTER.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G43X, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\..\..\firmware\CMSIS\core;..\..\..\firmware\CMSIS\device;..\..\..\firmware\n32g43x_std_periph_driver\inc;..\..\..\middlewares\rt-thread\include;..\..\..\middlewares\rt-thread\components\drivers\include\drivers;..\..\..\middlewares\rt-thread\components\drivers\include\ipc;..\..\..\middlewares\rt-thread\components\drivers\include;..\DeviceDrivers\gpio\inc;..\DeviceDrivers\uart\inc;..\APP\inc;..\modbus_rt\rtt_uart;..\modbus_rt\modbus_rt\modbus_rt;..\modbus_rt\modbus_rt\agile_modbus;..\modbus_rt\modbus_rt\slave_util;..\modbus_rt\modbus_rt\platform\rt_thread;..\..\..\middlewares\rt-thread\components\finsh;..\gnss_sk;..\gnss_sk\gps;..\gnss_sk\nmea;..\bsp;..\protocol;..\business;..\DeviceDrivers\spi\inc;..\DeviceDrivers\adc\inc;..\..\..\middlewares\rt-thread\components\drivers\spi;..\..\..\middlewares\rt-thread\components\drivers\spi\sfud\inc;..\DeviceDrivers\rtc\inc;..\protocol\gb905;..\gsm;..\utils;..\protocol\itop;..\protocol\http
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../../../firmware/CMSIS/device/startup/: startup_n32g43x.s
  group CMSIS
    ../../../firmware/CMSIS/device/: system_n32g43x.c
  group FWLB
    ../../../firmware/n32g43x_std_periph_driver/src/: misc.c n32g43x_gpio.c n32g43x_rcc.c n32g43x_usart.c n32g43x_exti.c n32g43x_spi.c n32g43x_adc.c n32g43x_rtc.c n32g43x_pwr.c n32g43x_flash.c
  group RT_Thread
    ../../../middlewares/rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c components.c cpu.c signal.c
  group CORTEX-M4
    ../../../middlewares/rt-thread/libcpu/cortex-m4/: context_rvds.S cpuport.c
  group USER
    ../APP/src/: main.c board.c n32g43x_it.c
  group Drivers
    ../../../middlewares/rt-thread/components/drivers/misc/: pin.c adc.c
    ../../../middlewares/rt-thread/components/drivers/serial/: serial.c
    ../../../middlewares/rt-thread/components/drivers/src/: completion.c
    ../../../middlewares/rt-thread/components/drivers/spi/: qspi_core.c spi_core.c spi_dev.c spi_flash_sfud.c
    ../../../middlewares/rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../middlewares/rt-thread/components/drivers/rtc/: rtc.c
  group Device_Drivers
    ../DeviceDrivers/adc/src/: drv_adc.c
    ../DeviceDrivers/gpio/src/: drv_gpio.c
    ../DeviceDrivers/uart/src/: drv_usart.c
    ../DeviceDrivers/spi/src/: drv_spi.c
    ../DeviceDrivers/rtc/src/: drv_rtc.c
  group DOC
    ../: README.txt
  group Platform
    ../modbus_rt/rtt_uart/: rtt_uart.c
    ../modbus_rt/modbus_rt/platform/rt_thread/: modbus_rt_platform_memory.c modbus_rt_platform_serial.c modbus_rt_platform_thread.c
  group Modbus_RT
    ../modbus_rt/modbus_rt/agile_modbus/: agile_modbus_rtu.c agile_modbus.c
    ../modbus_rt/modbus_rt/slave_util/: modbus_slave_util.c
    ../modbus_rt/modbus_rt/modbus_rt/: modbus_ascii.c modbus_data_trans.c modbus_rtu.c modbus_slave.c modbus_tcp.c
  group finsh
    ../../../middlewares/rt-thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_file.c shell.c symbol.c
  group gnss
    ../gnss_sk/: gnss_port.c gnss_sk.c gnss_if.c
    ../gnss_sk/gps/: GPS.c
    ../gnss_sk/nmea/: MicroNMEA.c
  group bsp
    ../bsp/: spi_flash_w25q.c bsp.c spi_file_sys.c
  group gsm
    ../gsm/: gsm.c cip_sockmgr.c
  group misc
    ../utils/: bcd.c cb_buffer.c
  group business
    ../business/: setting.c modbus_m.c status.c
  group protocol
    ../protocol/gb905/: gb905_control.c gb905_remote.c gb905_param.c gb905_report.c gb905_protocol.c
    ../protocol/itop/: itop_protocol.c itop_authorize.c
    ../protocol/http/: module_http.c http_client.c
