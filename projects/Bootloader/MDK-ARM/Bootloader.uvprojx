# Keil uVision project Bootloader.uvprojx, settings and files
target N32G43x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G435RB Nationstech
  pack: Nationstech.N32G43x_DFP.0.9.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BOOTLOADER-N32 +hex
  AfterMake: fromelf --bin --output=.\bin\boot-iap.bin .\Objects\BOOTLOADER-N32.axf
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G43X, USE_STDPERIPH_DRIVER
  c include: ..\APP\inc;..\..\..\firmware\CMSIS\core;..\..\..\firmware\CMSIS\device;..\..\..\firmware\n32g43x_std_periph_driver\inc;..\update
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../../../firmware/CMSIS/device/startup/: startup_n32g43x.s
  group CMSIS
    ../../../firmware/CMSIS/device/: system_n32g43x.c
  group FWLB
    ../../../firmware/n32g43x_std_periph_driver/src/: n32g43x_gpio.c n32g43x_rcc.c n32g43x_spi.c n32g43x_usart.c misc.c
  group USER
    ../APP/src/: main.c n32g43x_it.c spi_flash.c
    ../update/: datasave.c n32g43x_flash_slm.c public.c
